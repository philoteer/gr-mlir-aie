options:
  parameters:
    generate_options: no_gui
    id: speed
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: int
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: range(1,256)
  states: {}
- name: mlir_aie_mlir_aie_cpp_int32_0
  id: mlir_aie_mlir_aie_cpp_int32
  parameters:
    VECTOR_SIZE: '4096'
    kernel_name: MLIR_AIE
    path_insts_bin: /home/piloteer/xdna_phy/gr-mlir-aie/aie-kernel-src/simple_passthru/build/insts.bin
    path_xclbin: /home/piloteer/xdna_phy/gr-mlir-aie/aie-kernel-src/simple_passthru/build/final.xclbin
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [blocks_vector_source_x_0, '0', blocks_probe_rate_0, '0']
- [blocks_vector_source_x_0, '0', mlir_aie_mlir_aie_cpp_int32_0, '0']
- [mlir_aie_mlir_aie_cpp_int32_0, '0', blocks_int_to_float_0, '0']
- [mlir_aie_mlir_aie_cpp_int32_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
