options:
  parameters:
    generate_options: no_gui
    id: speed
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: mlir_aie_cbfloat_to_complex64_0
  id: mlir_aie_cbfloat_to_complex64
  parameters: {}
  states: {}
- name: mlir_aie_complex64_to_cbfloat_0
  id: mlir_aie_complex64_to_cbfloat
  parameters: {}
  states: {}
- name: mlir_aie_mlir_aie_cpp_int32_0
  id: mlir_aie_mlir_aie_cpp_int32
  parameters:
    VECTOR_SIZE: '4096'
    kernel_name: MLIR_AIE
    path_insts_bin: aie-kernel-src/cpp_cbfloat16_multikernel_chain_chesscc/build/insts.bin
    path_xclbin: aie-kernel-src/cpp_cbfloat16_multikernel_chain_chesscc/build/final.xclbin
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_probe_rate_0, '0']
- [analog_sig_source_x_0, '0', mlir_aie_complex64_to_cbfloat_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [mlir_aie_cbfloat_to_complex64_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_cbfloat_to_complex64_0, '0', qtgui_time_sink_x_0, '0']
- [mlir_aie_complex64_to_cbfloat_0, '0', mlir_aie_mlir_aie_cpp_int32_0, '0']
- [mlir_aie_mlir_aie_cpp_int32_0, '0', mlir_aie_cbfloat_to_complex64_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
